# Keil uVision project 2.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 1
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group Sources
    ./: main.c
