# Keil uVision project Blinky.uvproj, settings and files
target STM32F207 RAM (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group Source Files
    ./: GLCD_16bitIF_STM32F2xx.c Retarget.c Serial.c IRQ.c main.c tsc2046.c
  group Documentation
    ./: Abstract.txt
target STM32F207 Flash (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
