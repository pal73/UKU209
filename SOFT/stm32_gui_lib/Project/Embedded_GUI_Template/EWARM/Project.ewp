# IAR project Project.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Multi-Input Embedded GUI Library.bin
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
configuration STM32100E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD_VL; USE_STM32100E_EVAL
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL
  ILINK.IlinkOutputFile: STM32100E-EVAL.out
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
configuration STM32100B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL; USE_STM32100B_EVAL
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  ILINK.IlinkOutputFile: STM32100B-EVAL.out
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL; USE_3D_OBJECTS
  OBJCOPY.OOCOutputFile: Embedded GUI Library.bin
  ILINK.IlinkOutputFile: STM3210E-EVAL_XL.out
configuration STM322xG-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  OBJCOPY.OOCOutputFile: Embedded GUI Library.bin
  ILINK.IlinkOutputFile: STM322xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
configuration STM32L152-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\Embedded_GUI_Library\inc; ..\..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  OBJCOPY.OOCOutputFile: Embedded GUI Library.bin
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c system_stm32f2xx.c system_stm32l1xx.c
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group GUI_HAL
    ../../../Libraries/Embedded_GUI_HAL/src/: JoyHal.c LcdHal.c touchscreen.c TscHal.c
  group GUI_Library
    ../../../Libraries/Embedded_GUI_Library/src/: cursor.c gl_fonts.c graphicObject.c images.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_ioe.c stm32100e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_ioe.c stm322xg_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval_lcd.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c
  group User
    ../src/: hw_config.c main.c pictures.c stm32f10x_it.c stm32f2xx_it.c stm32l1xx_it.c uiappuser.c uiframework.c
